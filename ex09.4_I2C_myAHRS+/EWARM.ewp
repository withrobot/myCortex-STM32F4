# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F40_41xx; STM32F4XX; USE_STDPERIPH_DRIVER; TARGET_STM32F4XX=1; FEATURE_ASSERT_DBG=1
  ICCARM.CCIncludePath2: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32_CPAL_Driver\inc; ..\Libraries\STM32_CPAL_Driver\devices\stm32f4xx; ..\drv; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM.hex
  ILINK.IlinkOutputFile: EWARM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  group drv
    ../drv/: assert.c delay.c led.c llio.c startup_stm32f40xx.s system_stm32f4xx.c
  group lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/Debug/Exe/: STM32F4_StdPeriph_Driver.a
  group lib/CPAL
    ../Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
    ../Libraries/STM32_CPAL_Driver/devices/stm32f4xx/: cpal_i2c_hal_stm32f4xx.c
  group src
    ./: main.c

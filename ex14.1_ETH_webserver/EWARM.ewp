# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F4XX; STM32F40_41xxx; USE_STDPERIPH_DRIVER; TARGET_STM32F4XX=1; FEATURE_ASSERT_DBG=1
  ICCARM.CCIncludePath2: ; ..\drv; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32F4x7_ETH_Driver\inc; ..\Libraries\lwip-1.4.1\src\include\; ..\Libraries\lwip-1.4.1\src\include\lwip; ..\Libraries\lwip-1.4.1\src\include\netif; ..\Libraries\lwip-1.4.1\src\include\ipv4; ..\Libraries\lwip-1.4.1\port\STM32F4x7; ..\Libraries\lwip-1.4.1\port\STM32F4x7\Standalone\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM.hex
  ILINK.IlinkOutputFile: EWARM.out
  ILINK.IlinkIcfFile: ..\drv\stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drv
    ../drv/: assert.c led.c llio.c startup_stm32f40xx.s system_stm32f4xx.c
  group lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/Debug/Exe/: STM32F4_StdPeriph_Driver.a
  group lib/LwIP/Api
    ../Libraries/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lib/LwIP/Core
    ../Libraries/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lib/LwIP/Core/IPv4
    ../Libraries/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lib/LwIP/Netif
    ../Libraries/lwip-1.4.1/src/netif/: etharp.c
    ../Libraries/lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
  group lib/STM32F4x7_ETH_Driver
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group User
    ./: fs.c httpd.c httpd_cgi_ssi.c main.c netconf.c serial_debug.c stm32f4x7_eth_bsp.c stm32f4xx_it.c

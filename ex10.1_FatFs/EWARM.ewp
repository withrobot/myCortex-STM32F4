# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F40_41xx; USE_STDPERIPH_DRIVER; TARGET_STM32F4XX=1; FEATURE_ASSERT_DBG=1
  ICCARM.CCIncludePath2: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\drv; ..\Libraries\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM.hex
  ILINK.IlinkOutputFile: EWARM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group drv
    ../drv/: assert.c fatfs_diskio_spi.c fatfs_sdc_spi.c led.c llio.c startup_stm32f40xx.s system_stm32f4xx.c
  group lib
    ../Libraries/FatFs/src/: ff.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/Debug/Exe/: STM32F4_StdPeriph_Driver.a
  group src
    ./: main.c

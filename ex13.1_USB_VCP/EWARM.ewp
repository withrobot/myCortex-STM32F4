# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F4XX; STM32F40_41xxx; USE_STDPERIPH_DRIVER; USE_USB_OTG_FS; TARGET_STM32F4XX=1; FEATURE_ASSERT_DBG=1
  ICCARM.CCIncludePath2: ; ..\drv; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32_USB_Device_Library\Core\inc; ..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\Libraries\STM32_USB_OTG_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM.hex
  ILINK.IlinkOutputFile: EWARM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drv
    ../drv/: assert.c led.c llio.c startup_stm32f40xx.s system_stm32f4xx.c
  group lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/Debug/Exe/: STM32F4_StdPeriph_Driver.a
  group lib/USB Device/Class/CDC
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group lib/USB Device/Library
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group lib/USB Drivers
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group src
    ./: app.c stm32fxxx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
